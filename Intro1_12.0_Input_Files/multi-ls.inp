! ANSYS Intro Part 1 - Workshop 13C (insert file: multi-ls.inp)

! Axisymmetric Pipe with Fin Analysis

/FILN,multi-ls

WTIME=3

/NOPR
/PMETH,OFF,0
KEYW,PR_SET,1
KEYW,PR_STRUC,0
KEYW,PR_THERM,1
KEYW,PR_FLUID,0
KEYW,PR_MULTI,0
/GO

/TITLE, AXI-SYMMETRIC FIN WITH MULTIPLE LOAD STEPS - ESIZE=0.125

!########################################################
!#                                                      #
!#                     GEOMETRY                         #
!#                                                      #
!########################################################

/PREP7
! Solid Model
RECTNG,5,6,0,1
RECTNG,6,12,0,.25
  
AADD,all   
!*  Create fillet
LFILLT,10,7,.2, ,
FLST,2,3,4  
FITEM,2,5   
FITEM,2,8   
FITEM,2,2   
AL,5,8,2 

AADD,all
   
KWPAVE,       9 
wpro,,,90.000000
ASBW,       2
   
KWPAVE,       5 
wpro,,30.000000,
wpro,,30.000000,
wpro,,30.000000,
ASBW,       3   

KWPAVE,5,10 
wpro,,90.000000,
ASBW,2 
asbw,4

LCOMB,11,18 ,0  

LCCAT,11,12

! Prepare for meshing
LESIZE,5, , ,33,.25, , , ,0
LESIZE,7, , ,33,.25, , , ,0
LESIZE,2, , ,6, , , , ,0  
LESIZE,8, , ,3, , , , ,0  
LESIZE,11, , ,3, , , , ,0  
LESIZE,12, , ,3, , , , ,0  
LESIZE,17, , ,3, , , , ,0  

WPSTYLE,,,,,,,,0
lplot

!########################################################
!#                                                      #
!#                   THERMAL ANALYSIS                   #
!#                                                      #
!########################################################

! Axisymmetric option
ET,1,PLANE55, , , 1 
MAT,1,  
/COM,Typical material properties for DEMO purposes only 
/NOP
/COM,Internal UNITS set at file creation time = BIN 
TBDEL,ALL,_MATL 
MPDEL,ALL,_MATL 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,EX  ,_MATL , 1,  27992720.0    , 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,NUXY,_MATL , 1, 0.290000000    , 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,ALPX,_MATL , 1, 9.888888889E-06, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,DENS,_MATL , 1, 7.514795200E-04, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,KXX ,_MATL , 1, 2.182244000E-04, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,C   ,_MATL , 1,  46.2864080    , 
/GO 
!*  
MPLIST,1
TBLIST,ALL,1
!*  
MSHAPE,0,2D 
MSHKEY,1
ESIZE,0.25/2
AMESH,ALL   
FINISH 
 
/SOLU   
SFL,2,CONV,0.69e-4, ,70 
SFL,6,CONV,0.69e-4, ,70 
SFL,7,CONV,0.69e-4, ,70 
SFL,10,CONV,0.69e-4, ,70
SFL,9,CONV,0.28e-3, ,450
SFL,13,CONV,0.28e-3, ,450   
GPLOT   
SAVE
SOLVE   
FINISH 



!#########################################################
!#                                                       #
!#                  STRUCTURAL ANALYSIS                  #
!#                                                       #
!#########################################################

/NOPR
/PMETH,OFF,0
KEYW,PR_SET,1
KEYW,PR_STRUC,1
KEYW,PR_THERM,0
KEYW,PR_FLUID,0
KEYW,PR_MULTI,0
/GO

/PREP7  
LSCLEAR,SOLID   				! Clear all thermal loads
ETCHG,TTS   				! Thermal to Structural
KEYOPT, 1, 3, 1 				! Axisymmetric option

DL,3, ,SYMM 				! Structural symmetry constraints
DL,5, ,SYMM 
DL,11, ,SYMM

NSEL,S,LOC,Y,1  				! Couple top nodes
CP,1,UY,ALL 

ALLSEL,ALL  

/PBF,TEMP, ,1  				! Turn on temperature load contours 
EPLOT   

SAVE

/SOLU                                 !moved to multi-ls.inp from ws13C - no coupled field
LDREAD,TEMP,,,,,multi-ls,rth


