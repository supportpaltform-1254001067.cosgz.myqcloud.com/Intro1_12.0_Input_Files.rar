! ANSYS Intro Part 1 - Workshop 6C-1

finish
/clear,start

~SATIN,crank-assy,sat,,SOLIDS,0
/FACET,NORML
/PREP7
/PNUM,VOLU,1
VPLOT
