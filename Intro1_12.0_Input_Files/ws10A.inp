! ANSYS Intro Part 1 - Workshop 10A

finish
/clear,start

/filn,bracket-3d
resume,bracket-3d,db1

/TITLE, 3-D Bracket linear struct. analysis (SOLID95s and ESIZE=0.15)

/SOLU
EPLOT
DA,3,SYMM
DA,4,SYMM
DA,5,SYMM
DA,6,SYMM

D,4282,UZ

SFA,11,1,PRES,1000

! Solve
EQSLV,PCG,1E-8
SAVE
SOLVE
SAVE

/POST1
PLNSOL,S,EQV
/VIEW,1,-0.5,-0.25,1
/REPLOT
