! ANSYS Intro Part 1 - Workshop 14d

RESUME,multi-ls,db

/POST1  
INRES,ALL   
FILE,'multi-ls','rst','.'   

SET,,,,,,,2 
PLESOL,S,EQV
! /UIS,ABORT,1  
/SHOW,WIN32 
/REPLOT,RESIZE  


! User now enters Result Viewer interactively.
