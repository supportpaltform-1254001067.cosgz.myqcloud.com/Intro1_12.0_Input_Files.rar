! ANSYS Intro Part1 - Workshop 14A



/GRA,POWER
/GST,ON
/PLO,INFO,3



! Define Parameters using *ASK
*ASK,height,plate height,6
*ASK,width,plate width,6
*ASK,dia,diameter of hole,2
*ASK,pressure,pressure load,-1000

thick=1
elmsiz=.1
modulus=30e6
elmdiv=30

/prep7
rect,0,width,0,height
aplot
cyl4,0,0,dia/2
asba,1,2

! Define Element Type
et,1,42,,,3

! Define Real Constants for PLANE42
r,1,thick

! Define Material Properties
mp,ex,1,modulus

! Element Size
esize,elmsiz

! Apply Symmetry
lsel,s,loc,x,0
lsel,a,loc,y,0
dl,all, ,symm

! Apply Mesh Divisions
lesize,all, , ,elmdiv,1/5, , , ,1
lsel,s,loc,x,width
lsel,a,loc,y,height
lesize,all, , ,elmdiv/2, , , , ,1
lccat,all

! Mesh
mshape,0,2D
mshkey,1
amesh,all
eplot

! Apply Loads
lsel,s,loc,x,width
sfl,all,pres,pressure
allsel,all,line

save
finish

! Solution
/solu
solve
save

! Post-Process
/post1
set,1,1
plnsol,s,x
