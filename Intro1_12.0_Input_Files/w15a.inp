
! ANSYS 11.0 Intro Part 1 - Workshop 15A

finish
/clear,start

*ABBR,PLATE,/INPUT,PLATE-15A,INP

/INPUT,PLATE-15A,INP

/WAIT,10

ABBSAV

finish
/clear,start

ABBRES,NEW,plate-15A,abbr

/INPUT,PLATE-15A,INP
