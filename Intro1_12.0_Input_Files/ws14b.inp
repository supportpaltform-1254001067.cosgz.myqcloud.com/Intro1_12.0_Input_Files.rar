! ANSYS Intro Part 1 - Workshop 13B

finish
/clear,start

/INPUT,shell,inp

WTIME=3

/GRAPHICS,POWER

/POST1
!/VIEW,1,-1,1,1
!/DIST,1,3.976

/EFACET,2

PLNSOL,S,X
/WAIT,WTIME
PLNSOL,S,Y
/WAIT,WTIME
PLNSOL,S,Z
/WAIT,WTIME
PLNSOL,S,EQV
SHELL,MID
/REPLOT

RSYS,2
SHELL,TOP
/ESHAPE,1
/GLINE,1,-1

PLNSOL,S,X
/WAIT,WTIME
PLNSOL,S,Y
/WAIT,WTIME
PLNSOL,S,Z
/WAIT,WTIME
PLNSOL,S,EQV

