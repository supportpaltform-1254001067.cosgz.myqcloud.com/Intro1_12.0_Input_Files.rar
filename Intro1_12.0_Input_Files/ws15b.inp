! ANSYS Intro Part 1 - Workshop 15B

finish
/clear,start

/filn,bracket2d

! Dimensions
rad1 = 0.4
r_fillet = 0.4
d1 = 6
d2 = 4
d3 = 2

! Element Type
e_type = 82
e_size = 0.25

! Real Constants
thick = 0.5

! Material Properties for A36 Steel
ex1 = 30e6
p_ratio = .27

PARSAV,SCALAR,bracket2d,prm

/TITLE, 2-D bracket built and meshed using parameters
/PREP7

! Solid Model
BLC5,d1/2,0,d1,d3
BLC5,d1-d3/2,-d2/2+d3/2,d3,d2
CYL4, , ,d3/2
CYL4,d1-d3/2,-d2+d3/2,d3/2

AADD,ALL
! Line Fillet
LFILLT,18,24,r_fillet
AL,1,3,4

AADD,ALL
CYL4, , ,rad1
CYL4,d1-d3/2,-d2+d3/2,rad1

ASBA,2,ALL

! Mesh the model
ET,1,e_type
KEYOPT,1,3,3
R,1,thick
MP,EX,1,ex1
MP,PRXY,1,p_ratio

SMRTSIZE,4
ESIZE,e_size
MSHAPE,0,2D
MSHKEY,0
AMESH,all

SAVE,bracket2d-mesh,db1
