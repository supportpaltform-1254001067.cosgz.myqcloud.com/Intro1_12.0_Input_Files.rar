! ANSYS Intro Part 1 - Workshop 12A (insert file: pipe-th.inp)

/TITLE, 2D AXI-SYMM THERMAL ANALYSIS W/ CONV. LOADING - ESIZE=0.125

/PREP7
! Solid Model
RECTNG,5,6,0,1
RECTNG,6,12,0,.25
  
AADD,all   
!*  Create fillet
LFILLT,10,7,.2, ,
FLST,2,3,4  
FITEM,2,5   
FITEM,2,8   
FITEM,2,2   
AL,5,8,2 

AADD,all
   
KWPAVE,       9 
wpro,,,90.000000
ASBW,       2
   
KWPAVE,       5 
wpro,,30.000000,
wpro,,30.000000,
wpro,,30.000000,
ASBW,       3   

KWPAVE,5,10 
wpro,,90.000000,
ASBW,2 
asbw,4

LCOMB,11,18 ,0  

LCCAT,11,12

! Prepare for meshing
LESIZE,5, , ,33,.25, , , ,0
LESIZE,7, , ,33,.25, , , ,0
LESIZE,2, , ,6, , , , ,0  
LESIZE,8, , ,3, , , , ,0  
LESIZE,11, , ,3, , , , ,0  
LESIZE,12, , ,3, , , , ,0  
LESIZE,17, , ,3, , , , ,0  

WPSTYLE,,,,,,,,0
lplot

