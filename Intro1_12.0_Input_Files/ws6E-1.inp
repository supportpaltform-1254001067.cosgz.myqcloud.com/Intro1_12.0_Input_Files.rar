! ANSYS Intro Part 1 - Workshop 6E-1

finish
/clear,start

~PARAIN,wheel-assy,x_t,,SOLIDS,0,0
/FACET,NORML
/PREP7
/PNUM,VOLU,1
VPLOT
