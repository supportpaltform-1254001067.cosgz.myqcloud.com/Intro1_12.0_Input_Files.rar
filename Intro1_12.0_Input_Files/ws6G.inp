! ANSYS Intro Part 1 - Workshop 6G
! Bottom-up connecting rod problem

finish
/clear,start

/filn,c-rod

/PREP7  
PCIRC,1.4,1,0,180
PCIRC,1.4,1,45,180
/PNUM,AREA,1
RECTNG,-0.3,0.3,1.2,1.8
RECTNG,-1.8,-1.2,0,0.3
WPSTYLE,,,,,,,,1 
WPAVE,6.5
CSYS,4
PCIRC,0.7,0.4,0,180
PCIRC,0.7,0.4,0,135
/AUTO,1
APLOT

AOVLAP,1,2,3,4
AOVLAP,5,6

CSYS,0  
K, ,2.5,0.5
K, ,3.25,0.4
K, ,4.0,0.33
K, ,4.75,0.28

! Create Spline
CSYS,1

BSPLIN,5,6,7,21,24,22,1,135,,1,45
LSTR,1,18

AL,6,1,7,25

LFILLT,36,40,.25
LFILLT,40,31,0.25
LFILLT,30,39,0.25
  
AL,12,10,13
AL,17,15,19
AL,23,21,24

AADD,ALL
CSYS,0
ARSYM,Y,13, , , ,0,0
AADD,ALL
WPSTYLE
SAVE
SAVE,c-rod,db1
