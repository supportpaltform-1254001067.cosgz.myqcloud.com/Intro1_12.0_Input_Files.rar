/PREP7  
BLOCK,0,5,0,5,0,10
BLOCK,0,5,0,5,0,-10
KWPLAN,-1,1,3,9
CYL4,2.5,5,1.5, , , ,-10  
KWPLAN,-1,1,9,10
CYL4,5,2.5,1.75, , , ,-10
vsel,u,,,1
vsbv,2,all
vsel,all
vglue,all

et,1,45
et,2,95
mpread,Al_a2024-T3,BIN_MPL,,lib

WPSTYLE,,,,,,,,0
/view,,1,1,1
/triad,lbot
/color,outl,black
save,hextet,db
