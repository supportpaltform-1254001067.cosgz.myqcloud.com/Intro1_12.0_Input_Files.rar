fini
/clear
!
/prep7  
block,-2,2,0,2,-2,2,
vplot   
/view, 1 ,1,2,3 
/ang, 1 
/rep,fast   
sphere,2.5,2.7,0,360,   
vplot   
vinv,all
vplot   
