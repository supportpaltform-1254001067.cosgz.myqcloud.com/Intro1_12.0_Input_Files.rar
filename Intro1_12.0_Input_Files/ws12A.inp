! ANSYS Intro Part 1 - Workshop 12A

finish
/clear,start

/FILN,pipe-th

/NOPR
/PMETH,OFF,0
KEYW,PR_SET,1
KEYW,PR_STRUC,0
KEYW,PR_THERM,1
KEYW,PR_FLUID,0
KEYW,PR_MULTI,0
/GO

/TITLE, 2D AXI-SYMM THERMAL ANALYSIS W/ CONV. LOADING - ESIZE=0.125
/PREP7

! Geometry
/INPUT,pipe-th,inp,,, 0

! Axisymmetric option
ET,1,PLANE55, , , 1 


!/MPLIB,READ,e:\temp\57_files\ansfiles\final_files   
!/MPLIB,WRITE,   
!*  
!*  
MAT,1,  
! /INPUT,e:\temp\57_files\ansfiles\final_files\Stl_AISI-304.BIN_MPL 
! ANSYS REVISION 5.7, $RCSfile: Stl_AISI-304.BIN_MPL $  
! Modified on $Date: 2000/06/01 19:20:22 $  
! Source ID = $Revision: 7.1 $  
/COM,Typical material properties for DEMO purposes only 
/NOP
/COM,Internal UNITS set at file creation time = BIN 
TBDEL,ALL,_MATL 
MPDEL,ALL,_MATL 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,EX  ,_MATL , 1,  27992720.0    , 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,NUXY,_MATL , 1, 0.290000000    , 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,ALPX,_MATL , 1, 9.888888889E-06, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,DENS,_MATL , 1, 7.514795200E-04, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,KXX ,_MATL , 1, 2.182244000E-04, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,C   ,_MATL , 1,  46.2864080    , 
/GO 
!*  
MPLIST,1
TBLIST,ALL,1
!*  
MSHAPE,0,2D 
MSHKEY,1
ESIZE,0.25/2
AMESH,ALL   
FINISH 
 
/SOLU   
SFL,2,CONV,0.69e-4, ,70 
SFL,6,CONV,0.69e-4, ,70 
SFL,7,CONV,0.69e-4, ,70 
SFL,10,CONV,0.69e-4, ,70
SFL,9,CONV,0.28e-3, ,450
SFL,13,CONV,0.28e-3, ,450   
GPLOT   
SAVE
SOLVE   
FINISH 
 
/POST1  
PLNSOL,TEMP 
PLNSOL,TF,SUM   
PLNSOL,TG,SUM   
FINISH  

