! ANSYS Intro Part 1 - Workshop 10B

finish
/clear,start

/filn,conn-rod
resume,conn-rod,db1

/TITLE, Connecting Rod linear structural analysis using half-symmetry

/SOLU
EPLOT
DA,8,SYMM
DA,9,SYMM

DA,7,SYMM
DA,10,SYMM
DA,13,SYMM

D,702,UZ

SFA,11,1,PRES,1000

! Solve
EQSLV,PCG,1E-8
SAVE
SOLVE
SAVE

/POST1
PLNSOL,S,EQV
/AUTO,1
/REPLOT
