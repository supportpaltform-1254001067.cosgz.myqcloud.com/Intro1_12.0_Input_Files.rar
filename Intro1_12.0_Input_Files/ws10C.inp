! ANSYS Intro Part 1 - Workshop 10C

finish
/clear,start

/filn,wheelb-omega
resume,wheelb-omega,db1

/TITLE, 3-D Wheel analysis with rotational velocity about Global Y

/SOLU

CMSEL,S,AREAS_1
APLOT
DA,ALL,SYMM

ALLSEL,ALL,AREA
EPLOT

! Symmetry B.C. on Front Faces
!DA,1,SYMM
!DA,2,SYMM
!DA,20,SYMM
!DA,27,SYMM
!DA,39,SYMM
!DA,40,SYMM

! Symmetry B.C. on Back Faces
!DA,6,SYMM
!DA,10,SYMM
!DA,21,SYMM
!DA,34,SYMM
!DA,41,SYMM

! Constrain UY DOF on Node 33 to Prevent Rigid Body Motion
D,33,UY

! Apply Rotational Velocity of 525 rad/sec = 5013 rpm
OMEGA,0,525

! Solve
EQSLV,PCG,1E-8
SAVE
SOLVE

/POST1
/EFACET,2
PLNSOL,S,EQV

CSYS,11
/EXPAND,16,LPOLAR,HALF,,22.5
/REPLOT
CSYS,0
