! ANSYS Intro Part 1 - Workshop 13E (insert file: plate-13e.inp)
! Plate with hole
! Report generator


fini
/clear

/filn,report

! Define Parameters
width=6
height=6
dia=2
thick=1
elmsiz=.1
pressure=-1000
modulus=30e6
elmdiv=15

/prep7
rect,0,width,0,height
aplot
cyl4,0,0,dia/2
asba,1,2

! Define Element Type
et,1,42,,,3

! Define Real Constants for PLANE42
r,1,thick

! Define Material Properties
mp,ex,1,modulus

! Element Size
esize,elmsiz

! Apply Symmetry
lsel,s,loc,x,0
lsel,a,loc,y,0
dl,all, ,symm

! Apply Mesh Divisions
lesize,all, , ,elmdiv,1/5, , , ,1
lsel,s,loc,x,width
lsel,a,loc,y,height
lesize,all, , ,elmdiv/2, , , , ,1
lccat,all

! Mesh
mshape,0,2D
mshkey,1
amesh,all
eplot

! Apply Loads
lsel,s,loc,x,width
sfl,all,pres,pressure
allsel,all,line

save
finish

! Solution
/solu
! eqslv,front
! direct,off
solve
save

finish
!/exit,all

! Post-Process
/post1
set,1,1
/dist,1,4.5
/UDOC,1,TYPE,RIGHT  
/UDOC,1,TYP2,RIGHT 
plnsol,s,x                   ! end of origonal file
/PBC,PATH,1 		     ! defining path operation
/PBC,PATH,0 
!*  
FLST,2,2,1  
FITEM,2,33  
FITEM,2,25  
!*  
PATH,Left,2,30,20,  
PPATH,P51X,1
PDEF,STAT   
!*  
PATH,LEFT   
PDEF,STAT   
!*  
AVPRIN,0,0, 
!*  
PDEF,L-SX,S,X,AVG   
/PBC,PATH, ,0   
!*  
PLPATH,L-SX 
!/EOF

/CONT,1,128,AUTO
/PLOPTS,MINM,OFF
/COLOR,U,BLUE   		! Blue BC lines
/PBC,ALL,,1 			! Plots BC's
/PBC,NFOR,,0
/PBC,RFOR,,0
/PSF,PRES,NORM,2,0,1		! Show Pressure load with arrows
/COLOR,CURVE,BLUE,1
/REPLOT 
plnsol,s,x
save

