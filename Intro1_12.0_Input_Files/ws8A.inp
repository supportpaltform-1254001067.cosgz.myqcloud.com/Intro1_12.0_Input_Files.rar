! ANSYS Intro Part 1 - Workshop 8A

fini
/clear

/FILNAME,usermat,		!define jobname
/PREP7  			!enter the preprocessor
!*  
MPTEMP,,,,,,,,			!define material 1  
MPTEMP,1,100
MPTEMP,2,200
MPTEMP,3,300
MPTEMP,4,400
MPTEMP,5,500
MPDATA,EX,1,,1.0E7  
MPDATA,EX,1,,7.5E6  
MPDATA,EX,1,,6.0E6  
MPDATA,EX,1,,5.0E6  
MPDATA,EX,1,,4.0E6  
MPDATA,PRXY,1,,0.30 
MPDATA,PRXY,1,,0.29 
MPDATA,PRXY,1,,0.29 
MPDATA,PRXY,1,,0.2750   
MPDATA,PRXY,1,,0.2750  
!*  
MPPLOT,ex,1			!plot EX of material 1   
!* 
MPCOPY, ,1,2			!copy material 1 to material 2
TBCOPY,ALL,1,2  			
!*
MPTEMP,,,,,,,,			!define material 2  
MPTEMP,1,100
MPTEMP,2,200
MPTEMP,3,300
MPTEMP,4,400
MPTEMP,5,500
MPDE,EX,2   
MPDE,EY,2   
MPDE,EZ,2   
MPDE,NUXY,2 
MPDE,NUYZ,2 
MPDE,NUXZ,2 
MPDE,PRXY,2 
MPDE,PRYZ,2 
MPDE,PRXZ,2 
MPDE,GXY,2  
MPDE,GYZ,2  
MPDE,GXZ,2  
MPDATA,EX,2,,5.0E6  
MPDATA,EX,2,,4.5E6  
MPDATA,EX,2,,3.0E6  
MPDATA,EX,2,,2.0E6  
MPDATA,EX,2,,1.0E6  
MPDATA,PRXY,2,,0.30 
MPDATA,PRXY,2,,0.30 
MPDATA,PRXY,2,,0.28 
MPDATA,PRXY,2,,0.28 
MPDATA,PRXY,2,,0.28

fini
!/exit