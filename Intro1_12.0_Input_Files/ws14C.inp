FINISH
/CLEAR,START
/INPUT,multi-ls,inp
/SOLU
! Load Step 1 - Thermal Loads
!/PSF,CONV,TBULK,0
LDREAD,TEMP,,,,,multi-ls,rth
/PBF,TEMP,,1
EPLOT

/TITLE, 2D AXI-SYMM STRUCTURAL ANALYSIS WITH THERMAL LOAD
SOLVE

! Delete Thermal Loads
BFDELE,ALL,TEMP
BFLIS,ALL

! Load Step 2 - Internal Pressure Load
! Apply internal constant pressure of 1000 psi
SFL,9,PRES,1000
SFL,13,PRES,1000

/PSF,PRES,NORM,2,0
/PBC,ALL,,0
EPLOT
SAVE

/TITLE, 2D AXI-SYMM STRUCTURAL ANALYSIS WITH INTERNAL PRESSURE

SOLVE

FINISH ! Exit Solution

/POST1
PLNSOL,S,EQV
/WAIT,WTIME

SET,1,1

PLNSOL,S,EQV
/WAIT,WTIME

LCDEF,2,2
LCOPER,ADD,2
/TITLE, 2D AXI-SYMM STRUCTURAL ANALYSIS WITH COMBINED LOADING
PLNSOL,S,EQV
/WAIT,WTIME

/EXPAND,9,AXIS,,,10,,2,RECT,HALF,,0.00001
/VIEW,1,1,1,1
/AUTO,1
!/EDGE,1,1,45
!/GLINE,1,0	! Solid element outlines (default)
!/GLINE,1,1	! Dashed element outlines
/GLINE,1,-1	! No element outlines
/REPLOT
/WAIT,WTIME

PLNSOL,U,SUM
/WAIT,WTIME
PLNSOL,S,X
/WAIT,WTIME
PLNSOL,S,Y
/WAIT,WTIME
PLNSOL,S,Z
/WAIT,WTIME
RAPPND,3,3
SAVE
FINISH
!/EXIT,ALL
