! ANSYS Intro Part 1 - Workshop 6E-2

finish
/clear,start

~PARAIN,base,x_t,,SOLIDS,0,0
~PARAIN,left-bracket,x_t,,SOLIDS,0,0
~PARAIN,right-bracket,x_t,,SOLIDS,0,0
~PARAIN,pin,x_t,,SOLIDS,0,0
~PARAIN,wheel,x_t,,SOLIDS,0,0
/FACET,NORML
/PREP7
/PNUM,VOLU,1
VPLOT
