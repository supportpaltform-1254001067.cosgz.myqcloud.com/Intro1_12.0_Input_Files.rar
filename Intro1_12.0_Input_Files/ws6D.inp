! ANSYS Intro Part 1 - Workshop 6D

finish
/clear,start

~PARAIN,bracket,x_t,,SOLIDS,0,0
/FACET,NORML
/PREP7
VPLOT
