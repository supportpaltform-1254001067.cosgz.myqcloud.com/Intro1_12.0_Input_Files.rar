! ANSYS Intro Part 1 - Workshop 7E

finish
/clear,start

/filn,impeller

RESUME,impeller,db1

WTIME = 3
GPLOT
/WAIT,WTIME

/PREP7

ET,2,SOLID45
TYPE,2

EXTOPT,ESIZE,2
VDRAG,ALL,,,,,,1
EPLOT
/WAIT,WTIME

EXTOPT,ESIZE,9

ASEL,S,LOC,Z,0.25
APLOT
/WAIT,WTIME

FLST,5,20,5,ORDE,20
FITEM,5,27
FITEM,5,48
FITEM,5,52
FITEM,5,59
FITEM,5,78
FITEM,5,84
FITEM,5,90
FITEM,5,95
FITEM,5,98
FITEM,5,104
FITEM,5,110
FITEM,5,115
FITEM,5,121
FITEM,5,128
FITEM,5,138
FITEM,5,145
FITEM,5,149
FITEM,5,157
FITEM,5,167
FITEM,5,173
ASEL,R, , ,P51X
APLOT
/WAIT,WTIME

VDRAG,ALL,,,,,,2

ALLSEL,ALL
EPLOT
SAVE,impeller-mesh,db1


