! ANSYS Intro Part 1 - Workshop 6C-2

finish
/clear,start

~SATIN,knob,sat,,SOLIDS,0
~SATIN,plate,sat,,SOLIDS,0
~SATIN,socket,sat,,SOLIDS,0
/FACET,NORML
/PREP7
/PNUM,VOLU,1
VPLOT
