! ANSYS Intro Part 1 - Workshop 6B

finish
/clear,start

~SATIN,gear,sat,,SOLIDS,0
/FACET,NORML
/PREP7
VPLOT
