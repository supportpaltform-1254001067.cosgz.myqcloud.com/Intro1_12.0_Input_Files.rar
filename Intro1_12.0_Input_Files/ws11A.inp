! ANSYS Intro Part 1 - Workshop 11A

fini
/clear,start

/NOPR
/PMETH,OFF,0
KEYW,PR_SET,1
KEYW,PR_STRUC,1
KEYW,PR_THERM,0
KEYW,PR_FLUID,0
KEYW,PR_MULTI,0
/GO

/TITLE, Lathe Cutter

/AUX15                       !Step 3 Import IGES file
IOPTN,IGES,NODEFEAT 
IOPTN,MERGE,YES 
IOPTN,SOLID,YES 
IOPTN,SMALL,YES 
IOPTN,GTOLER, DEFA  
IGESIN,'cutter','igs',' ' 

/VIEW,1,-2,2,3
VPLOT

/PREP7

! convert cm to inches
VLSCAL,all,,,1/2.54,1/2.54,1/2.54, ,0,1      !Step 4 Scale Volumes
VPLOT

/INPUT,cutter-area,inp                       !Step 5 Read in cutter-area.inp

ET,1,SOLID92                                 !Step 6 Select Element type

mp,ex,1,10e6                                 !Step 7 Material properties
mp,prxy,1,0.32

SMRT,4                                       !Step 8 Meshing
MSHAPE,1,3D
MSHKEY,0
VMESH,all

/VIEW,1,-2,2,3
eplot

!/ui,copy,save, jpeg,graph,color,reverse,portrait
!/sys,rename cutter000.jpg cuttere.jpg
FINISH  

/SOLU   

DA,18,SYMM                                   !Step 9 Apply Symmetry to Areas
DA,19,SYMM
DA,25,SYMM
DA,26,SYMM

SFA,1,1,PRES,10000                           !Step 10 Apply Pressure to the Tip

! iterative solver already set
SOLVE                                        !Step 11 Solve
FINISH

/POST1
/title,Lathe Cutter - with AREA SYMMETRY constraint at hole
!PLNSOL,U,SUM,2,1                             !Step 12a Plot Displacements
!PRRSOL                                       !Step 12b List Reactions
!PLNSOL,S,EQV,0,1                             !Step 12c Plot Von-Mises Stress
!PLNSOL,S,EQV                                 !Step 12e Animate Von-Mises Stress
!ANCNTR,10,0.5

/wait,2
! solve again with altered restraints
/SOLU
DADELE,18,ALL                                 !Step 13 Delete Symmetry Constraints
DADELE,19,ALL
DADELE,25,ALL
DADELE,26,ALL
 
DA,18,ALL                                     !Step 14 Apply Constraints in all DOF
DA,19,ALL
DA,26,ALL
                                              !Step 15 Change title
/title,Lathe Cutter - with ALL DOF constraint on areas at hole

SOLVE                                         !Step 16 Solve

/POST1
PLNSOL,S,EQV                                  !Step 17 Plot Von-Mises Stress and Compare

!fini
!/exit,all
