! ANSYS Intro Part 1 - Workshop 6H
! Connecting Rod - Importation / Clean-up

finish
/clear,start

/filn,c-rod-fix

/AUX15  				! Read IGES file
IOPTN,IGES,NODEFEAT 
!*  
IOPTN,MERGE,YES 
IOPTN,SOLID,YES 
IOPTN,SMALL,YES 
IOPTN,GTOLER, DEFA  
IGESIN,c-rod,igs,
VPLOT     
FINISH 

/PREP7  

KCENTER,KP,17,29,31,0 		! Cut large hole in rod  
KWPAVE, 1   
CYL4, , ,1, , , ,-1 
VSBV,1,2
VPLOT  
 
KCENTER,KP,19,23,27,0  		 ! Cut small hole in rod 
KWPAVE, 18  
CYL4, , ,.4, , , ,-1
VSBV,3,1
VPLOT 

  
WPRO,,90,  				! Split the rod in half 
VSBW,2  
VDELE,3, , ,1   
VPLOT
   
AFILLT,47,43,1, 			! Create the fillet
AL,2,12,18  
AL,1,13,30  
VA,8,10,12,13,15
VADD,all
VPLOT   
AADD,14,16  
AADD,12,6   
VPLOT   

SAVE
FINISH

!/EXIT,ALL,