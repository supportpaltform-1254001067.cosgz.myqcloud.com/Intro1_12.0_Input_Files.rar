! ANSYS Intro Part 1 - Workshop 7F

finish
/clear,start

/filn,wheelb-3d

RESUME,wheelb,db1

/TITLE, Mixed Free & Mapped Mesh of 3-D Wheel Model
/PREP7
VPLOT

VSBW,1
VPLOT
KWPAVE,19
VSBW,4
WPSTYLE
VPLOT

ESIZE,0.25
MSHAPE,0,3D
MSHKEY,1
VMESH,1,3,1
VMESH,5

TYPE,2
ESIZE,0.2
MSHAPE,1,3D
MSHKEY,0
VMESH,6

TCHG,95,92,0
ESEL,S,TYPE,,2
EPLOT
/WAIT,5
ALLSEL,ALL
EPLOT

SAVE,wheelb-3d-mesh,db1
