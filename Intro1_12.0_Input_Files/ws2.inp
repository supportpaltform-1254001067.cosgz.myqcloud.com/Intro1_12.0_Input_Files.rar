/prep7
mp,ex,1,30e6
mp,nuxy,1,0.3
et,1,plane42
blc4,0,0,10,1
amesh,all
nsel,s,loc,x,0
d,all,ux
alls
d,node(0,0.5,0),uy
f,node(10,1,0),fy,-100
/solu
solve
/post1
plns,u,y