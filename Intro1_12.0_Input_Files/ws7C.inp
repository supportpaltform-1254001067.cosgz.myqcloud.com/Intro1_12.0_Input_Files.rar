! ANSYS Intro Part 1 - Workshop 7C

finish
/clear,start

/filn,c-rod-mesh

RESUME,c-rod-2d,db1

/TITLE, 3D brick element mesh created using 2D MESH200 elements and VOFFST (ESIZE=0.2)
/PREP7

ET,1,MESH200
KEYOPT,1,1,7

APLOT

ESIZE,0.15
MSHAPE,0,2D
MSHKEY,0
amesh,all

! /EFACET,2
EPLOT

save,c-rod-2d-mesh-quad,db-2d
/WAIT,3

:SWEEP
! Sweep the 2-d mesh into bricks
ET,2,95

EXTOPT,ESIZE,3
/VIEW,1,1,1,1
APLOT
VOFFST,2,.5

SAVE,c-rod-mesh-brick2,db1
EPLOT

/WAIT,3

:VSWEEP1
! Redo using VSWEEP to create a 3D brick element mesh

finish
/clear,start
RESUME,c-rod-fix,db1

/TITLE, 3D brick element mesh created using VSWEEP and Auto Src/Trg (ESIZE=0.2)
/PREP7
ET,1,95

/VIEW,1,1,1,1
VPLOT

ESIZE,0.2
VSWEEP,ALL

SAVE,c-rod-mesh-sweep,db1
EPLOT
