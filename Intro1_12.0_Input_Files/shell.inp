! ANSYS Intro Part 1 - Workshop 13B (insert file: shell.inp)

! Spherical Shell Analysis (1/4 model)

/FILNAM,shell

/TITLE,Postprocessing of spherical shell with internal press. of 500 psi

/PREP7
ET,1,SHELL93
R,1,.1
MP,EX,1,1e7
!
/VIEW,1,-1,1,1
/DIST,1,3.976

SPHERE,5,4,0,90
VDELE,1
CSYS,2
ASEL,U,LOC,X,4
ADELE,ALL,,,1
ALLSEL,ALL,AREA
CSYS,0
ASBW,ALL
ADELE,3,,,1
APLOT

MSHAPE,0,2D
MSHKEY,1
ESIZE,0.25
AMESH,ALL
!/EFACET,2
EPLOT

/SOLU
ANTYPE,STATIC
!
DL,ALL,,SYMM
SFE,ALL,,PRES,,500

SOLVE
FINISH

/PBC,ALL,,0

