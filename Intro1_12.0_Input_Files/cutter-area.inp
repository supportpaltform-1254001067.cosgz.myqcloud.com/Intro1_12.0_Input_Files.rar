! ANSYS Intro Part 1 - Workshop 11A (insert file: cutter-area.inp)

! create a small area for 
! pressure loading at tip
KWPLAN,-1,14,12,13
WPOFF,0,0,-1/5
ASBW,22
WPSTYLE,,,,,,,,0
/VIEW,1,-2,2,3
/PNUM,AREA,1
APLOT
/title,Lathe Cutter - with AREA SYMMETRY constraint at hole
