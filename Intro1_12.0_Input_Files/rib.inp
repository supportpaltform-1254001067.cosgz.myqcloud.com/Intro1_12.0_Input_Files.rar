/prep7  
k,1,1,2  
k,2,3,2 
k,3,4   
k,4,1,1.5   
k,5,2.5 
csys,1  
l,4,5   
csys
a,5,3,2,1,4

et,1,82,,,3    ! Plane stress with thickness
r,1,1/8        ! Thickness = 1/8 in
mpread,Al_a2024-T3,BIN_MPL,,lib
/color,outl,black
save,ribfull,db

k,100   
k,101,,1
CYL4,2.25,1.5,0.3   
CYL4,3.,.6,0.35 
ASBA,1,all
aplot   
save,ribgeom,db

esize,.05
amesh,all
eplot
save,rib,db
save,ribmesh,db

csys,0
lsel,,loc,x,1
dl,all,,ux
lsel,,loc,y,0
dl,all,,uy
lsel,all
f,node(2,2,0),fy,-100
save,ribfy,db

