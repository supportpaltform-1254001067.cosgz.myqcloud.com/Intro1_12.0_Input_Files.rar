! ANSYS Intro Part 1 - Workshop 14e
! Report Generator

FINISH
/CLEAR,START

/INPUT,plate-13e,inp,	! Read input file to create & solve plate with hole


! Start of report captures. 

~tcl,'package require ansys '
~tcl,'ansys::report::setdirectory "plate_report" '   
/REPLOT,RESIZE 
 
EPLOT   
~tcl,'ansys::report::imagecapture "Plot of Elements" '  

PLNSOL,S,X,0,1  
~tcl,'ansys::report::imagecapture "X-direction Stress" '
PLPATH,L-SX 
~tcl,'ansys::report::imagecapture "Graph of SX Stress on Path L-SX" '  
 
~tcl,'ansys::report::animcapture "Animation of Deformed Results" 100'   
/REPLOT,RESIZE  
PLNSOL,S,X  
ANCNTR,10,0.5 
  
~tcl,'ansys::report::tablecapture 2 "Material Properties" 1'
~tcl,'ansys::report::tablecapture 4 "Reaction Forces"' 
 
fsum,,1 
fsum,,1 
fsum,,1 

~tcl,'ansys::report::outputcapture "List of Stress along Path L-SX" "prpath,l-sx"'  
prpath,l-sx 

~tcl,'ansys::report::outputcapture "List of Constraints on Selected Items" "sbclis"'
sbclis  


!######################################
!	Create the HTML Report          #
!######################################

*CREATE,plate_report,html,plate_report 
 
<html>  
<head>  
<title>Analysis of Plate with Hole</title>  
   <script LANGUAGE="JavaScript1.2" SRC="ansysImages.js"> </script> 
   <script LANGUAGE="JavaScript1.2" SRC="ansysAnimations.js"> </script> 
   <script LANGUAGE="JavaScript1.2" SRC="ansysTables.js"> </script> 
   <script LANGUAGE="JavaScript1.2" SRC="ansysListings.js"> </script>   
   <script> ie4 = (document.all ? true : false); </script>  
   <style type="text/css"></style>  
</head> 
<body>  
<!-- Report Heading --> 
<table border=0 cellpadding=7 width=95%>
<tr>
<td align=center>   
<h1>
Analysis of Plate with Hole 
</h1>   
</td>   
</tr>   
<tr>
<td align=center>   
<h3>
By John Doe 
</h3>   
</td>   
</tr>   
<tr>
<td align=center>   
<b> 
January 04, 2001
</b>
</td>   
</tr>   
<tr>
<td align=center>   
<h2>
X-Company   
</h2>   
</td>   
</tr>   
<tr>
<td align=center>   
<b> 
Report Generated by ANSYS   
</b>
</td>   
</tr>   
</table>
<p><hr></p> 
<!-- HTML Text -->  
The purpose of this analysis was to analyze a plate with a hole.
<ansys> 
! ANSYS Commands (for list commands use the 
! toolbar's Listing Capture button) 
/nopr   
*get,revision,active,0,rev  
*vwrite,revision
(f3.1)  
</ansys>
<!-- HTML Text -->  
revision of ANSYS.  
<center>
<script>
<!--
image_1('Plot of Elements');
//-->   
</script>   
</center>   
<center>
<script>
<!--
image_2('X-direction Stress');  
//-->   
</script>   
</center>   
<center>
<script>
<!--
animseq_1('Animation of Deformed Results'); 
//-->   
</script>   
</center>   
<center>
<script>
<!--
image_3('Graph of SX Stress on Path L-SX'); 
//-->   
</script>   
</center>   
<blockquote>
<script>
<!--
listing_1('List of Stress along Path L-SX');
//-->   
</script>   
</blockquote>   
<blockquote>
<script>
<!--
listing_2('List of Constraints on Selected Items'); 
//-->   
</script>   
</blockquote>   
<blockquote>
<script>
<!--
table_1('Material Properties'); 
//-->   
</script>   
</blockquote>   
<blockquote>
<script>
<!--
table_2('Reaction Forces'); 
//-->   
</script>   
</blockquote>   
</body> 
</html> 
*END
~tcl,'ansys::report::interpdynamicdata plate_report/plate_report.html plate_report/plate_report.html '  

FINISH
!/EXIT,NOSAVE
