! ANSYS Intro Part 1 - Workshop 7A

finish
/clear,start

/filn,silo

RESUME,silo,db1

/TITLE, Select Logic and Solid Model Attributes
/PREP7
APLOT

! Cylinder areas
ASEL,S,LOC,Z,0,120
APLOT
AATT, 2, 1, 1

! Upper part of cone areas
ASEL,S,LOC,Z,-30,0
APLOT
AATT, 1, 2, 1

! Lower part of cone areas
ASEL,S,LOC,Z,-60,-30
APLOT
AATT, 1, 3, 1

! Cone Lines
LSEL,S,LOC,Z,-60,0
LPLOT
LATT, 1, 4, 2

! Mesh the model
LMESH,ALL

/WAIT,3

ALLSEL,ALL
APLOT
AMESH,ALL

!SAVE,silo-mesh,db1
