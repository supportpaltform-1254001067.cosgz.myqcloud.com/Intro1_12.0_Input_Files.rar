! ANSYS Intro Part 1 - Workshop 6A

finish
/clear,start

/AUX15  
IOPTN,IGES,NODEFEAT
!*  
IOPTN,MERGE,YES 
IOPTN,SOLID,YES 
IOPTN,SMALL,YES 
IOPTN,GTOLER, DEFA  
IGESIN,bracket,igs,

/TITLE, bracket.igs  
VPLOT   
