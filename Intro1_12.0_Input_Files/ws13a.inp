! ANSYS 11.0 Intro Part 1 - Workshop 13A
FINISH
/CLEAR,START
RESUME,pipe-th,db,,0,0 
/NOPR   
/PMETH,OFF,0
KEYW,PR_SET,1   
KEYW,PR_STRUC,1 
KEYW,PR_THERM,0 
KEYW,PR_FLUID,0 
KEYW,PR_ELMAG,0 
KEYW,MAGNOD,0   
KEYW,MAGEDG,0   
KEYW,MAGHFE,0   
KEYW,MAGELC,0   
KEYW,PR_MULTI,0 
KEYW,PR_CFD,0   
KEYW,LSDYNA,0   
/GO   
/COM,   
/COM,Preferences for GUI filtering have been set to display:
/COM,  Structural   
/TITLE,2D AXI-SYMM THERMAL-STRESS ANALYSIS W/ INT. PRESS - ESIZE=0.125 
/PREP7  
LSCLEAR,SOLID   		! Clear all thermal loads
ETCHG,TTS   			! Thermal to Structural
KEYOPT, 1, 3, 1 		! Axisymmetric option
LDREAD,TEMP, , , , ,pipe-th,rth   ! Read temps from thermal results

DL,3, ,SYMM 		! Structural symmetry constraints
DL,5, ,SYMM 
DL,11, ,SYMM

NSEL,S,LOC,Y,1  	! Couple top nodes
CP,1,UY,ALL 

ALLSEL,ALL  

SFL,9,PRES,1000 ! Apply 1000 psi to internal lines
SFL,13,PRES,1000

/PBF,TEMP, ,1  	! Turn on temperature load contours 
EPLOT   

SAVE
FINISH

/SOLU   
SOLVE   
FINISH  

/POST1  		! Plot results
PLNSOL,U,SUM,2,1
PLNSOL,S,EQV
PLNSOL,S,X 
 
/EXPAND, 9,AXIS,,,10,,2,RECT,HALF,,0.00001 	
! Sweep results for 3-D 
/VIEW,1,1,1,1   
/REPLOT 
PLNSOL,S,Y  
PLNSOL,S,Z  
FINISH  
!/exit,all

