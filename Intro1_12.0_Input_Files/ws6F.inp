! ANSYS Intro Part 1 - Workshop 6F

finish
/clear,start

/filn,p-block

/PREP7  
BLOCK,0,3,0,1,0,3,  
/VIEW, 1 ,1,1,1 
wpoff,2.25, 1.25, .75   
wprot,0,-90,0   
CYL4, , ,0.75/2, , , ,-1.5  
VGEN,2,2, , , , ,1.5, ,0 
VPLOT   
VSBV,1,ALL
WPCSYS,-1,0
VPLOT
BLC4,0,1,1.5,1.75,0.75 
KWPAVE,16
CYL4,0,0,0,0,1.5,90,-0.75
CYL4,0,0,1, , , ,-0.1875
CYL4,0,0,0.85, , , ,-2

! Subtract the solid cylinders from the bushing bracket
FLST,2,2,6,ORDE,2   
FITEM,2,1   
FITEM,2,-2  
VSBV,P51X,       3  
FLST,2,2,6,ORDE,2   
FITEM,2,6   
FITEM,2,-7  
VSBV,P51X,       5  

! Merge keypoints
NUMMRG,KP, , , ,LOW

! Create the triangular web
KBETW,7,8,0,RATI,0.5
A,14,15,9
!*
VOFFST,3,-0.15

VGLUE,ALL
/PNUM,VOLU,1
VPLOT
SAVE
SAVE,p-block,db1
