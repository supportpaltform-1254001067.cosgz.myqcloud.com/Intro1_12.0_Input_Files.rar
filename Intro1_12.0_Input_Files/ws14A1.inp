! ansys intro part 1 - workshop 14a

finish
/clear,start

*abbr,plate,/input,plate-14a,inp

/input,plate-14a,inp

/wait,10

abbsav

finish
/clear,start

abbres,new,plate-14a,abbr

/input,plate-14a,inp
