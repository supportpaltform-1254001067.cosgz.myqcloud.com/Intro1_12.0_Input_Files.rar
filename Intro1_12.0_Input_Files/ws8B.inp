! ANSYS Intro Part 1 - Workshop 8B

fini
/clear

/FILNAME,userlib,0 			!define jobname 
/PREP7  
!*  
MPTEMP,,,,,,,, 				!define material 1 
MPTEMP,1,200
MPTEMP,2,400
MPTEMP,3,800
MPTEMP,4,1000   
MPTEMP,5,1200   
MPDATA,EX,1,,8E6
MPDATA,EX,1,,5E6
MPDATA,EX,1,,4.5E6  
MPDATA,EX,1,,3E6
MPDATA,EX,1,,2e6
MPDATA,PRXY,1,,0.3  
MPDATA,PRXY,1,,0.3  
MPDATA,PRXY,1,,0.28 
MPDATA,PRXY,1,,0.28 
MPDATA,PRXY,1,,0.28 
*CSET,1,2,       1,2,   
!*
MPCOPY, ,1,2				!copy material 1 to material 2
TBCOPY,ALL,1,2  
!*  
MPTEMP,,,,,,,,				!define material 2  
MPTEMP,1,93.33  
MPTEMP,2,204.44 
MPTEMP,3,426.67 
MPTEMP,4,537.78 
MPTEMP,5,648.89 
MPDE,EX,2   
MPDE,EY,2   
MPDE,EZ,2   
MPDE,NUXY,2 
MPDE,NUYZ,2 
MPDE,NUXZ,2 
MPDE,PRXY,2 
MPDE,PRYZ,2 
MPDE,PRXZ,2 
MPDE,GXY,2  
MPDE,GYZ,2  
MPDE,GXZ,2  
MPDATA,EX,2,,5.52e10
MPDATA,EX,2,,3.45e10
MPDATA,EX,2,,3.10e10
MPDATA,EX,2,,2.07e10
MPDATA,EX,2,,1.38e10
MPDATA,PRXY,2,,0.3  
MPDATA,PRXY,2,,0.3  
MPDATA,PRXY,2,,0.28 
MPDATA,PRXY,2,,0.28 
MPDATA,PRXY,2,,0.28
!* 
MPWRITE,material_bfin,user,,lib,1	!write material 1 to a file   
MPWRITE,material_SI,user,,lib,2 	!write material 2 to a file
!*
FINISH  
/CLEAR,START				!clear the database
/PREP7  
!*  

MAT,1,					!import material 1  
/INPUT,material_bfin.user 

MAT,2,  
/INPUT,material_SI.user 		!import material 2

MPPLOT,EX,1				!plot EX of material 1

fini
!/EXIT