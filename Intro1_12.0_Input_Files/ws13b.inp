! ANSYS 11.0 Intro Part 1 - Workshop 13B

FINISH
/CLEAR,START
/input,pipe-th,inp 
wsec=2 	! wait in seconds between plots

/prep7
ET,1,PLANE13	! Coupled thermal/structural, axisymmetric element
KEYOPT,1,1,4
KEYOPT,1,3,1

MSHAPE,0,2D 		! Mesh all areas
MSHKEY,1
ESIZE,0.25/2
AMESH,ALL  
 
MAT,1,  
/COM,Typical material properties for DEMO purposes only 
/NOP
/COM,Internal UNITS set at file creation time = BIN 
TBDEL,ALL,_MATL 
MPDEL,ALL,_MATL 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,EX  ,_MATL , 1,  27992720.0    , 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,NUXY,_MATL , 1, 0.290000000    , 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,ALPX,_MATL , 1, 9.888888889E-06, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,DENS,_MATL , 1, 7.514795200E-04, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,KXX ,_MATL , 1, 2.182244000E-04, 
MPTEMP,R5.0, 1, 1, 0.000000000E+00, 
MPDATA,R5.0, 1,C   ,_MATL , 1,  46.2864080    , 

/GO   
MPLIST,1
TBLIST,ALL,1
SFL,2,CONV,0.69e-4, ,70 	! Apply thermal film coefficients
SFL,6,CONV,0.69e-4, ,70 
SFL,7,CONV,0.69e-4, ,70 
SFL,10,CONV,0.69e-4, ,70
SFL,9,CONV,0.28e-3, ,450
SFL,13,CONV,0.28e-3, ,450
SFL,9,PRES,1000        ! Apply structural internal pressure
SFL,13,PRES,1000

NSEL,S,LOC,Y,1         ! Couple the top nodes
CP,1,UY,ALL 
ALLSEL,ALL  
DL,3, ,SYMM	! Structural symmetry constraints
DL,5, ,SYMM 
DL,11, ,SYMM
SAVE
/SOLU   
SOLVE   
FINISH 
 /POST1  
PLNSOL,TEMP 		! Plot nodal temps
/wait,wsec
PLNSOL,U,SUM,2,1      ! Plot displacement with deformed edge
/wait,wsec
PLNSOL,S,EQV		! Plot von Mises

/EXPAND, 9,AXIS,,,10,,2,RECT,HALF,,0.00001  ! Expand to 3-D
/VIEW,1,1,1,1 
/wait,wsec  
/REPLOT 
/wait,wsec
PLNSOL,TEMP 
