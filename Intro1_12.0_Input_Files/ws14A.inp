! ANSYS Intro Part 1 - Workshop 14A

finish
/clear,start

/filn,conn-rod

!Resume the "conn-rod.db2" database file
resume,conn-rod,db1
/prep7
SFA,11,1,PRES,1000

/SOLU
DA,2,ALL
SOLVE

! Set wait time between plots (seconds)
WTIME=3

/TITLE, Connecting Rod Postprocessing with ESIZE=0.2

/POST1
PLNSOL,S,EQV
/AUTO,1
/REPLOT

/WAIT,WTIME

EPLOT

PATH,PATH1,2,30,20
PPATH,1,824
PPATH,2,1029

PATH,PATH2,2,30,20
PPATH,1,1029
PPATH,2,521

PDEF,P2-SEQV,S,EQV,AVG
PDEF,P2-SX,S,X,AVG
PDEF,P2-SY,S,Y,AVG
PDEF,P2-SZ,S,Z,AVG

PLPATH,P2-SEQV
/WAIT,WTIME
PLPATH,P2-SX
/WAIT,WTIME
PLPATH,P2-SY
/WAIT,WTIME
PLPATH,P2-SZ
/WAIT,WTIME
PLPATH,P2-SEQV,P2-SX,P2-SY,P2-SZ
/YRANGE,-1000,1900
/AXLAB,X,Path2 Distance
/AXLAB,Y,Stress, psi
/REPLOT
/WAIT,WTIME

PATH,PATH1
PDEF,P1-SEQV,S,EQV,AVG
PDEF,P1-SX,S,X,AVG
PDEF,P1-SY,S,Y,AVG
PDEF,P1-SZ,S,Z,AVG

/YRANGE,DEFAULT
/AXLAB,X
/AXLAB,Y

PLPATH,P1-SEQV
/WAIT,WTIME
PLPATH,P1-SX
/WAIT,WTIME
PLPATH,P1-SY
/WAIT,WTIME
PLPATH,P1-SZ
/WAIT,WTIME
PLPATH,P1-SEQV,P1-SX,P1-SY,P1-SZ
/YRANGE,-1100,1800
/AXLAB,X,Path1 Distance
/AXLAB,Y,Stress, psi
/REPLOT
/WAIT,WTIME
/COLOR,OUTL,BLAC
/PBC,PATH,1
/REPLOT
/PBC,PATH,0
/COLOR,OUTL,WHIT
/WAIT,WTIME
FINISH
/GRAPHICS,FULL

/POST1
PLESOL,SERR
/WAIT,WTIME
PLESOL,SDSG
/WAIT,WTIME
PLNSOL,U,SUM
/WAIT,WTIME
PLNSOL,S,EQV
/WAIT,WTIME

FINISH

/TITLE, Connecting Rod Postprocessing with ESIZE=0.1
/PREP7
ESIZE,0.1
EPLOT
VCLEAR,ALL
VSWEEP,ALL
/SOLU
D,2932,UZ
SOLVE

/POST1
PLESOL,SERR
/WAIT,WTIME
PLESOL,SDSG
/WAIT,WTIME
PLNSOL,U,SUM
/WAIT,WTIME
PLNSOL,S,EQV
/WAIT,WTIME

SAVE,conn-rod2,db1
FINISH
/EXIT,NOSAVE
