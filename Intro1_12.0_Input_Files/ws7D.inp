! ANSYS Intro Part 1 - Workshop 7D

finish
/clear,start

/filn,cotter-pin

RESUME,cotter,db1

/TITLE, 3D brick/wedge element mesh created using VSWEEP and Auto Src/Trg (AESIZE=0.01)
/PREP7
/VIEW,1,1,2,3
VPLOT

AESIZE,21,0.01
AESIZE,40,0.01
VSWEEP,ALL
EPLOT

SAVE,cotter-pin-mesh,db1
