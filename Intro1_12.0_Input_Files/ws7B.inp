! ANSYS Intro Part 1 - Workshop 7B

finish
/clear,start

RESUME,p-block,db1

/filn,p-block-mesh

/PREP7

ET,1,SOLID95

VPLOT

SMRT,4
MSHAPE,1,3D
MSHKEY,0
VMESH,ALL
EPLOT
/eof
!SAVE,p-block-mesh-free,db1

/WAIT,3

VCLEAR,ALL
VPLOT

KWPLAN,-1,15,14, 9
vsbw,all

allsel
KWPLAN,-1,  17, 10, 18
VSBW, 6  
ADRAG, 46, , , , , ,78 
VSBA, 7,  23 
ADRAG,49, , , , , ,47   
VSBA, 5,  24  
allsel
ESIZE,.125
VSWEEP,ALL
!SAVE,p-block-mesh-sweep,db1
